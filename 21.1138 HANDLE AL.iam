# Autodesk Inventor assembly: 21.1138 HANDLE AL
## iProperties
Created: 2007-02
Part Number: 21.1138 HANDLE AL
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
